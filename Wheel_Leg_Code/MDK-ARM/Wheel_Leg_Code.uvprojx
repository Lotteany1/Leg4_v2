# Keil uVision project Wheel_Leg_Code.uvprojx, settings and files
target Wheel_Leg_Code (ARM-ADS)
  device: STM32H723VGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Wheel_Leg_Code +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_EXTERNAL_SOURCE_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  asm include: as above
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c bdma.c cordic.c dma.c fdcan.c fmac.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cordic.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_fmac.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
